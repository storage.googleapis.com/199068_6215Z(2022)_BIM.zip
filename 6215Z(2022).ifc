Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-21T20:06:16
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20191106_1200(x64) - Exporter 20.2.1.1 - Alternate UI 20.2.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Oct 21 20:06:16 2023 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\00bcdd55-e729-4a74-9953-da3241b926e8\ba4933af-0e8b-4564-ac4d-c55b3fd6a10b\ifc * Database version: 5507 * Database creation date: Sat Oct 21 20:06:15 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Oct 21 20:06:15 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Oct 21 20:06:15 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 00902201 Cold water faucet, 6215Z(2022):00902201 Cold water faucet:433018
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - InletConnectionSize: 16 mm; NominalDepth: 216 mm; NominalHeight: 175.5 mm; NominalWidth: 90 mm
Type - General - Author: BIMStone; BIMObjectName: 00902201(2022); ManufacturerName: HANSA; ManufacturerURL: http://www.hansa.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 01/06/2023
Type - Green Building Properties - Approval ABP: PA-IX 38425/IO; EAN Number: 4057304019807; EN Standard: EN 817; ETIM Class Number: EC011375 Water tap; Noise Class: I (ISO 3822); Sales Package dimensions (LxWxH): 380 x 180 x 74; UNSPSC Class Number: 30181700 Faucets or taps; URL ABP: http://static.hansa.com/ABP/00902201; URL Declaration of Asbestos: http://static.hansa.com/doc/asbestos; URL Declaration of Conformity: http://static.hansa.com/DoC/00902201; URL Declaration Of Performance (DOP): http://static.hansa.com/doc/DoP; URL Declaration of SCIP: http://static.hansa.com/doc/SCIP; URL EcoLabel Declaration: http://static.hansa.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.hansa.com/doc/packaging; URL Materials Declaration: http://www.hansa.com/fileadmin/resources/169257_00902201_materialsdeclaration.pdf; URL REACH: http://static.hansa.com/doc/reach
Type - Identity Data - 2D/3D/BIM Files URL: http://static.hansa.com/bim/00902201; 3D View: https://static.hansa.com/AR/00902201; Catalog Drawing URL: http://static.hansa.com/catdrw/00902201; Dimension Drawing URL: http://static.hansa.com/dimdrw/00902201; FDV Document URL: http://www.hansa.com/datasheet/00902201/en/fdv; Flow Drawing URL: http://static.hansa.com/flowchart/00902201; Group: Washbasin faucet; Installation and Maintenance Guide URL: http://static.hansa.com/manual/00902201; Interactive AR View URL: https://static.hansa.com/AR/00902201; Manufacturer: HANSA; Market: International;Germany;Austria;Belgium;Netherlands;Italy; Mobile Product Information URL: http://mpi.hansa.com/00902201; Model: 00902201 Cold water faucet; Name_en: 00902201 Cold water faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 00902201; Product Family: HANSANOVA; Product Image URL: http://static.hansa.com/image/00902201; Product URL: http://static.hansa.com/00902201; Spare-Part Information URL: http://static.hansa.com/sp/00902201; Technical DataSheet URL: http://www.hansa.com/datasheet/00902201/en; Type Name: 00902201 Cold water faucet; Warranty Information URL: http://warranty.hansa.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Inner body made of DZR brass; Aerator: PCA® - constant flow rate regardless of pressure variations;Adjustable flow angle; Backflow Prevention EN1717: AA; Connection: One inlet for cold or premixed water; Connection Size: G3/8; Flow Rate At 300kPa With Flow Controller: 0.00353147 m3/s; Installation Type: Deck mounted; Lever Handle: Single operating lever/handle; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: Ceramic head part for flow control; Mounting Holes: 1 hole; Spout Projection: 84 mm; Spout Type: Fixed spout;Casted construction; Surface treatment: Chrome; Working Pressure: 50 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: HANSA; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 6215Z(2022); Features: Single-lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 00902201; Name: 00902201 Cold water faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 90x215x175 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ValveTypeCommon - ValvePattern: n/a; ValveOperation: n/a; ValveMechanism: n/a; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Polished
Pset_DistributionFlowElementCommon - Reference: 00902201 Cold water faucet; sets with these values: 2
Pset_ElementShading - Color: Chrome
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: 00902201; Manufacturer: HANSA
Pset_ProductRequirements - Name: 00902201 Cold water faucet; Category: Plumbing Fixtures
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.0750427 m2; Volume: 0.00342312 m3
Identity Data - Mark: 27
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 6215Z(2022): 00902201 Cold water faucet; Family and Type: 6215Z(2022): 00902201 Cold water faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 6215Z(2022): 00902201 Cold water faucet; Type Id: 6215Z(2022): 00902201 Cold water faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
